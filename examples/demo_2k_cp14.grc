options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: rx_demo_simple
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: active_carriers
  id: variable
  parameters:
    value: 13*108*2**(mode-1)+1
  states: {}
- name: data_carriers
  id: variable
  parameters:
    value: 13*96*2**(mode-1)
  states: {}
- name: guard
  id: variable
  parameters:
    value: 1.0/4
  states: {}
- name: mode
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6*64/63
  states: {}
- name: total_carriers
  id: variable
  parameters:
    value: 2**(10+mode)
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: test_out_layerB.ts
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: test_out_layerA.ts
    type: byte
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: test_out_layerC.ts
    type: byte
  states: {state: disabled}
- name: blocks_file_source_1_0
  id: blocks_file_source
  parameters:
    file: test_suite_0101.dat
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
    vlen: 96*2**(mode-1)
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: byte
    vlen: 96*2**(mode-1)*8
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_2
  id: blocks_vector_to_stream
  parameters:
    num_items: data_carriers
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: total_carriers
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(total_carriers)
  states: {state: disabled}
- name: isdbt_channel_decoding_0
  id: isdbt_channel_decoding
  parameters:
    constellation_size: '16'
    layer_segments: '8'
    mode: '1'
    rate: '0'
  states: {state: disabled}
- name: isdbt_channel_decoding_0_0
  id: isdbt_channel_decoding
  parameters:
    constellation_size: '4'
    layer_segments: '1'
    mode: '1'
    rate: '2'
  states: {}
- name: isdbt_channel_decoding_0_1
  id: isdbt_channel_decoding
  parameters:
    constellation_size: '64'
    layer_segments: '4'
    mode: '1'
    rate: '1'
  states: {state: disabled}
- name: isdbt_frequency_deinterleaver_0
  id: isdbt_frequency_deinterleaver
  parameters:
    mode: '1'
    oneseg: 'True'
  states: {}
- name: isdbt_ofdm_sym_acquisition_0
  id: isdbt_ofdm_sym_acquisition
  parameters:
    cp_length: int(guard*total_carriers)
    fft_length: total_carriers
    snr: '10'
  states: {state: disabled}
- name: isdbt_ofdm_synchronization_0
  id: isdbt_ofdm_synchronization
  parameters:
    cp_length: '0.250'
    interpolate: 'True'
    mode: '1'
  states: {}
- name: isdbt_symbol_demapper_0
  id: isdbt_symbol_demapper
  parameters:
    constellation_size_A: '4'
    constellation_size_B: '16'
    constellation_size_C: '64'
    mode: '1'
    segments_A: '1'
    segments_B: '8'
    segments_C: '4'
  states: {}
- name: isdbt_sync_and_channel_estimation_0
  id: isdbt_sync_and_channel_estimation
  parameters:
    offset_max: '10'
    transmission_mode: 2k
  states: {state: disabled}
- name: isdbt_time_deinterleaver_0
  id: isdbt_time_deinterleaver
  parameters:
    length_A: '0'
    length_B: '0'
    length_C: '8'
    mode: '1'
    segments_A: '1'
    segments_B: '8'
    segments_C: '4'
  states: {}
- name: isdbt_tmcc_decoder_0
  id: isdbt_tmcc_decoder
  parameters:
    print_params: 'True'
    transmission_mode: '1'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5.8e6/2.0
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 0.5e6
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: active_carriers
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"BER RS "'
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"BER Viterbi "'
    type: float
  states: {}

connections:
- [blocks_file_source_1_0, '0', blocks_throttle_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_number_sink_0, '0']
- [blocks_nlog10_ff_0_1, '0', qtgui_number_sink_0_0, '0']
- [blocks_throttle_0, '0', low_pass_filter_0, '0']
- [blocks_vector_to_stream_0_2, '0', qtgui_const_sink_x_0, '0']
- [fft_vxx_0, '0', isdbt_sync_and_channel_estimation_0, '0']
- [isdbt_channel_decoding_0, '0', blocks_file_sink_0, '0']
- [isdbt_channel_decoding_0, '1', blocks_nlog10_ff_0, '0']
- [isdbt_channel_decoding_0, '2', blocks_nlog10_ff_0_1, '0']
- [isdbt_channel_decoding_0_0, '0', blocks_file_sink_0_0, '0']
- [isdbt_channel_decoding_0_0, '1', blocks_nlog10_ff_0, '0']
- [isdbt_channel_decoding_0_0, '2', blocks_nlog10_ff_0_1, '0']
- [isdbt_channel_decoding_0_1, '0', blocks_file_sink_0_0_0, '0']
- [isdbt_channel_decoding_0_1, '1', blocks_nlog10_ff_0, '0']
- [isdbt_channel_decoding_0_1, '2', blocks_nlog10_ff_0_1, '0']
- [isdbt_frequency_deinterleaver_0, '0', isdbt_time_deinterleaver_0, '0']
- [isdbt_ofdm_sym_acquisition_0, '0', fft_vxx_0, '0']
- [isdbt_ofdm_synchronization_0, '0', isdbt_tmcc_decoder_0, '0']
- [isdbt_symbol_demapper_0, '0', blocks_null_sink_0, '0']
- [isdbt_symbol_demapper_0, '0', isdbt_channel_decoding_0_0, '0']
- [isdbt_symbol_demapper_0, '1', blocks_null_sink_0_0, '0']
- [isdbt_symbol_demapper_0, '1', isdbt_channel_decoding_0, '0']
- [isdbt_symbol_demapper_0, '2', isdbt_channel_decoding_0_1, '0']
- [isdbt_sync_and_channel_estimation_0, '0', isdbt_tmcc_decoder_0, '0']
- [isdbt_time_deinterleaver_0, '0', isdbt_symbol_demapper_0, '0']
- [isdbt_tmcc_decoder_0, '0', blocks_vector_to_stream_0_2, '0']
- [isdbt_tmcc_decoder_0, '0', isdbt_frequency_deinterleaver_0, '0']
- [low_pass_filter_0, '0', isdbt_ofdm_sym_acquisition_0, '0']
- [low_pass_filter_0, '0', isdbt_ofdm_synchronization_0, '0']

metadata:
  file_format: 1
